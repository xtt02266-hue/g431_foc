# Keil uVision project g431_foc.uvprojx, settings and files
target g431_foc (5060960::V5.06 update 7 (build 960)::.\armcc)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: g431_foc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../firmware/app;../firmware/app/private;../firmware/platform;../firmware/control;../firmware/compensation;../firmware/calibration;../firmware/drivers;../firmware/communication;../firmware/music;../firmware/algorithm;../firmware/config;../firmware/diagnostics
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Firmware/algorithm
    ../firmware/algorithm/: pid.c pid.h
  group Firmware/app
    ../firmware/app/: motor_calibration_session.c motor_control.c motor_control.h motor_haptic.c motor_host.c motor_host.h motor_modes.c motor_runtime.c motor_system.c motor_system.h motor_types.h
    ../firmware/app/private/: motor_context.c motor_context.h
  group Firmware/calibration
    ../firmware/calibration/: motor_calibration.c motor_calibration.h motor_encoder_calibration.c motor_encoder_calibration.h motor_identify.c motor_identify.h motor_parameters.c motor_parameters.h
  group Firmware/communication
    ../firmware/communication/: pc_protocol.c pc_protocol.h vofa_usart.c vofa_usart.h
  group Firmware/compensation
    ../firmware/compensation/: motor_cogging.c motor_cogging.h motor_friction.c motor_friction.h motor_friction_storage.c motor_friction_storage.h
  group Firmware/config
    ../firmware/config/: motor_config.h
  group Firmware/control
    ../firmware/control/: motor_current_loop.c motor_current_loop.h motor_position_loop.c motor_position_loop.h motor_speed_loop.c motor_speed_loop.h motor_trajectory.c motor_trajectory.h svpwm.c svpwm.h
  group Firmware/diagnostics
    ../firmware/diagnostics/: motor_debug.c motor_debug.h
  group Firmware/drivers
    ../firmware/drivers/: motor_encoder.c motor_encoder.h mt6826s.c mt6826s.h oled.c oled.h oled_font.h user_io.c user_io.h
  group Firmware/music
    ../firmware/music/: motor_music.c motor_music.h motor_songs.c motor_songs.h
  group Firmware/platform
    ../firmware/platform/: hardware_init.c hardware_init.h
  group Generated build dependencies
    ../Core/Src/: spi.c
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c
software components: CMSIS:CORE 4.3.0
